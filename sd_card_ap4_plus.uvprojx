# Keil uVision project sd_card_ap4_plus.uvprojx, settings and files
target sdio_ap4_plus (6180000::V6.18::ARMCLANG)
  device: AMAP42KP-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.3.0
  cpu: IRAM(0x10000000,0x002C0000) IROM(0x00018000,0x001E8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sd_card_ap4_plus +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4P keil
  c include: .\src;..\SDK\CMSIS\ARM\Include;..\SDK\CMSIS\AmbiqMicro\Include;..\SDK\utils;..\SDK\devices;..\SDK\boards\apollo4p_evb_disp_shield_rev2\bsp;..\SDK\mcu\apollo4p\hal\mcu;..\SDK\mcu\apollo4p\hal\dsp;..\SDK\mcu\apollo4p\hal;..\SDK\mcu\apollo4p
  memory RVCT4: ROM 0x18000 size 0x1e8000
  memory RVCT9: RAM 0x10000000 size 0x2c0000
  scatter file: .\linker_script.sct
  group src
    ./src/: am_resources.c bsp.c bsp.h sdhc.c sdhc.h am_memory_map.h sd_card.c sd_card.h sd_card_ap4_plus.c sd_card_gpio.c sd_card_gpio.h
  group keil
    ./keil/: startup_keil.s
  group util
    ../SDK/utils/: am_util_string.c am_util_string.h am_util_stdio.c am_util_stdio.h am_util_delay.c am_util_delay.h
  group hal
    ../SDK/mcu/apollo4p/hal/: am_hal_gpio.c am_hal_gpio.h am_hal_pin.c am_hal_pin.h am_hal_utils.h am_hal_pwrctrl.c am_hal_pwrctrl.h am_hal_global.c am_hal_global.h am_hal_dcu.c am_hal_dcu.h am_hal_adc.c am_hal_adc.h am_hal_queue.c am_hal_queue.h
    ../SDK/mcu/apollo4p/hal/mcu/: am_hal_card.c am_hal_card.h am_hal_card_host.c am_hal_card_host.h am_hal_clkgen.c am_hal_clkgen.h am_hal_mcu_interrupt.h am_hal_mcu_sysctrl.h am_hal_mcuctrl.c am_hal_mcuctrl.h am_hal_mpu.c am_hal_mpu.h am_hal_cachectrl.c am_hal_cachectrl.h am_hal_rtc.c am_hal_rtc.h am_hal_itm.c am_hal_itm.h am_hal_uart.c am_hal_uart.h am_hal_utils.c am_hal_tpiu.c am_hal_tpiu.h am_hal_interrupt.c am_hal_sdhc.c am_hal_sdhc.h am_hal_mram.c am_hal_mram.h am_hal_bootrom_helper.c am_hal_bootrom_helper.h
